Commit message: Corrected IMU pos

File: cartographer_ros/urdf/backpack_3d_kaibo.urdf (robot description, URDF)
Before this commit: robot cartographer_backpack_3d_kaibo, 3 links, 2 joints
Joints:
- joint imu_link_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0.882 rpy=0 0 0
